Commit message: conference rev

File: final_assembly.urdf (robot description, URDF)
Before this commit: robot quad_drone_mas, 21 links, 20 joints
Links:
- link connecting_stripes: geometry collision box size=1.2 1.2 0.02; visual box size=1.2 1.2 0.02
